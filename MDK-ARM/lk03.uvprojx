# Keil uVision project lk03.uvprojx, settings and files
target lk03 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lk03 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\zjk_src\boards\lk03; ..\zjk_src\sensor; ..\zjk_src\hal; ..\zjk_src\comToPC; ..\zjk_src\serial; ..\zjk_src\thinyFrame; ..\zjk_src\thinyFrame\demo; ..\zjk_src\task; ..\zjk_src\flash; ..\zjk_src\include; ..\zjk_src\ringBuffer; ..\zjk_src\modbus\include; ..\zjk_src\modbus\port; ..\zjk_src\modbus\rtu; ..\zjk_src\modbus\ascii; ..\zjk_src\z_sysos\z_include; ..\zjk_src\z_sysos
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group z_os/driver
    ../zjk_src/hal/: TDC_GP21.c z_analog.c
    ../zjk_src/serial/: z_serial.c
    ../zjk_src/sensor/: tlc5618.c
  group z_os/kernel
    ../zjk_src/z_sysos/z_include/: zdef.h z_os.h zdebug.h zos_service.c
  group z_os/board
    ../zjk_src/boards/lk03/: z_lko3.c
    ../zjk_src/flash/: z_flashParamSave.c
  group z_toPc
    ../zjk_src/comToPC/: Connect_Format.c
  group z_os/protecol/tinyFrame
    ../zjk_src/thinyFrame/demo/: test.c
    ../zjk_src/thinyFrame/: TinyFrame.c utils.c
    ../zjk_src/task/: z_param.h
  group z_os/tasks
    ../zjk_src/task/: z_freeRtos.c z_param.h z_sensor_ack.c
    ../zjk_src/ringBuffer/: ringQueue.c
    ../zjk_src/hal/: z_checksum.c
  group Middlewares/freeModbus
    ../zjk_src/modbus/: mb.c
    ../zjk_src/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../zjk_src/modbus/rtu/: mbcrc.c mbrtu.c
  group Middlewares/freeModbus/port
    ../zjk_src/modbus/port/: portevent.c portserial.c porttimer.c
    ../zjk_src/modbus/task/: mdtask.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dac.c dma.c freertos.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
software components: CMSIS:CORE 4.3.0
